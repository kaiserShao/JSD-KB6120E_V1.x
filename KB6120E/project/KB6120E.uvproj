# Keil uVision project KB6120E.uvproj, settings and files
target KB6120E (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: KB6120E +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG,STM32F10X_HD
  c include: ..\BIOS;..\RTOS;..\MODBUS;..\DEVICE;..\SD_USB;..\APP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group BIOS
    ../BIOS/: startup_stm32f10x_md.s STM32RTC.C STM32ADC.C BIOS.C Keyboard.C OLED9704.C TM12864.C CGROM.C Display.C Printer.C EE24.C CPS120.C BKPData.c
    ../SD_USB/: HAL_BASE.C SPI_HW.C SPI1Init.c
  group RTOS
    ../RTOS/: RTX_Conf_CM.c RTX_CM3.lib
  group MODBUS
    ../modbus/: MBM_Function.C MBM_IO.C MBM_RTU.C MBM_Port.C MBM_BIOS.C
  group Device
    ../APP/: Formulary.c SENSOR.c DataAccess.c SensorRead.c Sample.c Pump.c
    ../SD_USB/: FILE_SYS.C SD_USBPort.c
  group AppCore
    ../DEVICE/: Edit.c Menu.c
  group AppInterface
    ../APP/: Start.c Edition.c Monitor.c Query.c SampleSet.c Calibrate.c Configure.c ConfigureEx.c USBCopy.C
  group Note
    ../: note.txt
    ../../: V1.0更新说明.txt
